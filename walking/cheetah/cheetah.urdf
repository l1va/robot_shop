Commit message: Fix files cheetah to render

File: walking/cheetah/cheetah.urdf (robot description, URDF)
Before this commit: robot cheetah, 18 links, 17 joints
Links:
- removed link ground
Joints:
- removed joint ground_t_floating
